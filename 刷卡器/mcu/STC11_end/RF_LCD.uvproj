# Keil uVision project RF_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C664 Philips
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xFFFF) CLOCK(33000000) MODP2
  output: RF_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c key.c wifii.c Lcd.c rfid.c IAP.c AP170.c OS.c
