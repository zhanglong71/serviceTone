# Keil uVision project ZigBeePRO_DK_ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ZigBeePRO_DK_ADC +hex
  c flags: Optimize=9
  group Header
    ./H/: MCU.h INCLUDE_TOP.h PROJECT_OPTION.h PROJECT_TYPE.h ZSEC_TYPE.h INCLUDE_STACK.h ZAPS.h ZAPS_TYPE.h ZIGBEE_DEFINE.h ZMAC.h ZMAC_TYPE.h ZNWK.h ZNWK_TYPE.h ZSEC.h
  group LIB:COMMON
    ./LIB_FFD/: ZigBeePRO_FFD_LIB_MAIN_V22.LIB
  group LIB:BANK0
    ./LIB_FFD/: ZigBeePRO_FFD_LIB_SEC_V22.LIB ZigBeePRO_FFD_LIB_NWK_V22.LIB
  group LIB:BANK1
    ./LIB_FFD/: ZigBeePRO_FFD_LIB_APS_V22.LIB ZigBeePRO_FFD_LIB_MAC_V22.LIB
  group HAL:BANK1
    ./C_HAL/: UART.c PHY.c FLASH.c WDT.c TIMER.c SECURITY.c POWER.c KEYSCAN.c QUAD.c
  group USER:BANK1
    ./C_UTIL/: UTIL_SYS.c UTIL_APP.c
  group USER:COMMON
    ./C_USER/: ISR_USER.c Z_USER_DATA.c Z_USER_APP_TYPE.h Z_USER_ZDP.c
    ./C_USER/App_ADC/: Z_USER_CONFIG_ADC.h Z_USER_ADC.c
  group OTA:BANK3
    ./C_USER/: REBOOT.C
